# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\HARDWARE\CHINESE\W25QXX;..\HARDWARE\CHINESE\SDIO;..\FATFS\exfuns;..\FATFS\src;..\MALLOC;..\TEXT;..\TASK\lcd_task;..\TASK\getsensor_task;..\TASK\actuator_task;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\GPIO;..\HARDWARE\SPI;..\HARDWARE\IIC;..\HARDWARE\KEYBOARD;..\HARDWARE\LCD;..\HARDWARE\DH11;..\HARDWARE\MOTOR;..\HARDWARE\SOILHUMI;..\HARDWARE\SGP30;..\HARDWARE\GY30;..\HARDWARE\PH;..\HARDWARE\LOGIN;..\HARDWARE\TOUCH;..\HARDWARE\TOUCH\24CXX;..\HARDWARE\USART2;..\HARDWARE\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEYBOARD/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DH11/: dht11.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/SOILHUMI/: soilhumi.c
    ../HARDWARE/SGP30/: sgp30.c
    ../HARDWARE/CHINESE/W25QXX/: w25qxx.c
    ../HARDWARE/CHINESE/SDIO/: sdio_sdcard.c
    ../HARDWARE/LOGIN/: login.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/24CXX/: 24cxx.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/GY30/: gy30.c
    ../HARDWARE/PH/: ph.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/ESP8266/: esp.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group TASK
    ../TASK/lcd_task/: lcd_task.c
    ../TASK/getsensor_task/: getsensor_task.c
    ../TASK/actuator_task/: actuator_task.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c text.c
